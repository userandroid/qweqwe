# Keil uVision project uart.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: uart
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\USER;..\HARDWARE
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/: uart.c led.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
